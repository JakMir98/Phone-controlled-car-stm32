# Keil uVision project RemoteControlledCarBareMetal.uvprojx, settings and files
target STM32F411RE (6140001::V6.14.1::ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RemoteControlledCarBareMetal
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ./: main.c gpio.c uart.c systemClock.c pwm.c
  group inc
    ./: gpio.h uart.h systemClock.h pwm.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
